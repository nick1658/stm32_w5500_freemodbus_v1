# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (6090000::V6.9::.\ARMCLANG)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5500;..\..\User\usart;..\..\User\led;..\..\User\I2C_EEPROM;..\..\User\spi;..\..\User\bsp_dht11;..\..\User\TimBase
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c bsp_usart1.h
    ../../User/led/: bsp_led.c bsp_led.h
    ../../User/I2C_EEPROM/: bsp_i2c_ee.c bsp_i2c_ee.h bsp_i2c_gpio.c bsp_i2c_gpio.h
    ../../User/spi/: bsp_spi_flash.c bsp_spi_flash.h
    ../../User/bsp_dht11/: bsp_dht11.c bsp_dht11.h
    ../../User/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
  group W5500
    ../../User/Ethernet/W5500/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h
  group Internet
    ../../User/Ethernet/Internet/: tcp_demo.c tcp_demo.h udp_demo.c udp_demo.h dhcp.c dhcp.h dns.c dns.h smtp.c smtp.h http_server.c http_server.h http_client.c http_client.h httputil.c httputil.h netbios.c netbios.h ntp.c ntp.h weibo.c weibo.h ping.c ping.h webpge.h
software components: CMSIS:CORE 5.1.1
