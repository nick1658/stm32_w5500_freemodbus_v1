# Keil uVision project boot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\system;.\output;.\flib\inc;.\flib\src;.\word\24c02;.\word\device;.\word\spi;.\word\socket;.\word\md5;.\word\ult;.\word\usart;.\word\w5500;.\word\dhcp;.\word\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./User/: main.c stm32f10x_it.c stm32f10x_it.h tcp_udp.c tcp_udp.h stm32f10x_conf.h config.h types.h tftp.c tftp.h
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group flib
    ./flib/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_exti.c
  group word
    ./word/device/: device.c device.h
    ./word/md5/: md5.c md5.h
    ./word/socket/: socket.c socket.h
    ./word/spi/: spi2.c spi2.h
    ./word/ult/: ult.c ult.h
    ./word/usart/: usart.c usart.h
    ./word/w5500/: w5500.c w5500.h
    ./word/dhcp/: dhcp.c dhcp.h
    ./word/flash/: flash.c flash.h
