# Keil uVision project app.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\system;.\flib\inc;.\flib\src;.\output;.\word\device;.\word\ult;.\word\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h types.h config.h
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group flib
    ./flib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c
  group app
    ./word/device/: device.c device.h
    ./word/ult/: ult.c ult.h
    ./word/usart/: usart.c usart.h
